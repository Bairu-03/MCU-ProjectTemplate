<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Build\MSP430_IAR_Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
