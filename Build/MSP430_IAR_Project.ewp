# IAR project MSP430_IAR_Project.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\Library\MSP430F5xx_6xx\inc; ..\Library\MSP430F5xx_6xx; ..\User\Config; ..\User\Module; ..\User; ..\Driver\Car; ..\Driver\Encoder; ..\Driver\I2C_Hardware; ..\Driver\I2C_Software; ..\Driver\MPU6050; ..\Driver\nRF24L01; ..\Driver\OLED; ..\Driver\PWM; ..\Driver\SysClock; ..\Driver\UART; ..\Middleware\Algorithm\PID
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group Driver
    ../Driver/Car/: Car.c
    ../Driver/Encoder/: Encoder.c
    ../Driver/I2C_Software/: I2C_Sim.c
    ../Driver/MPU6050/: MPU6050.c
    ../Driver/I2C_Hardware/: MSP430F5529_I2C.c
    ../Driver/UART/: MSP430F5529_UART.c
    ../Driver/nRF24L01/: nRF24L01.c
    ../Driver/OLED/: OLED.c OLED_BMP.c OLED_Font.c
    ../Driver/PWM/: PWM.c
    ../Driver/SysClock/: Sys_Clock.c
  group Library
    ../Library/MSP430F5xx_6xx/: adc10_a.c adc12_a.c aes.c battbak.c comp_b.c crc.c ctsd16.c dac12_a.c dma.c eusci_a_spi.c eusci_a_uart.c eusci_b_i2c.c eusci_b_spi.c flashctl.c gpio.c lcd_b.c lcd_c.c ldopwr.c mpy32.c oa.c pmap.c pmm.c ram.c ref.c rtc_a.c rtc_b.c rtc_c.c sd24_b.c sfr.c sysctl.c tec.c timer_a.c timer_b.c timer_d.c tlv.c ucs.c usci_a_spi.c usci_a_uart.c usci_b_i2c.c usci_b_spi.c wdt_a.c
  group Middleware
    ../Middleware/Algorithm/PID/: PID.c
  group User
    ../User/: main.c
