# IAR project STM8L_IAR_Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; NDEBUG
  ICCSTM8.CCIncludePath2: ..\Library\STM8L15x_StdPeriph_Driver\inc; ..\Library\STM8L15x_StdPeriph_Driver\src; ..\Library; ..\Middleware\Algorithm; ..\Middleware\Protocol; ..\Middleware\Utils; ..\User\Config; ..\User\Module; ..\User\Module\test; ..\User; ..\Driver\ADC; ..\Driver\EEPROM; ..\Driver\KEY; ..\Driver\LED; ..\Driver\SysClk; ..\Driver\Timer; ..\Driver\UART
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8L_IAR_Project.srec
  ILINK.IlinkOutputFile: STM8L_IAR_Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Driver
    ../Driver/ADC/: ADC.c
    ../Driver/EEPROM/: EEPROM.c
    ../Driver/KEY/: KEY.c
    ../Driver/LED/: LED.c
    ../Driver/SysClk/: SysClk.c
    ../Driver/Timer/: Timer.c
    ../Driver/UART/: UART.c
  group Library
    ../Library/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    ../User/: main.c
    ../User/Config/: stm8l15x_it.c
    ../User/Module/test/: test.c
