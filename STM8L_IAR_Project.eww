<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Build\STM8L_IAR_Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
