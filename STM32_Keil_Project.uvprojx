# Keil uVision project STM32_Keil_Project.uvprojx, settings and files
target STM32F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Keil_Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Library\CMSIS\CoreSupport;.\Library\CMSIS\startup\arm;.\Library\CMSIS;.\Library\STM32F10x_StdPeriph_Driver\inc;.\Library\STM32F10x_StdPeriph_Driver\src;.\User\Config;.\User\Module;.\User;.\Middleware\Algorithm\PID;.\Driver\I2C_Hardware;.\Driver\I2C_Software;.\Driver\InfTrack;.\Driver\Motor;.\Driver\MPU6050;.\Driver\nRF24L01;.\Driver\OLED;.\Driver\PWM;.\Driver\UART;.\Driver\SysDelay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./Library/CMSIS/startup/arm/: startup_stm32f10x_md.s
    ./Library/CMSIS/CoreSupport/: core_cm3.c
    ./Library/CMSIS/: system_stm32f10x.c
  group Library
    ./Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Middleware
    ./Middleware/Algorithm/PID/: PID.c
  group Driver
    ./Driver/I2C_Hardware/: I2C_Hardware.c
    ./Driver/I2C_Software/: I2C_Software.c
    ./Driver/InfTrack/: InfTrack.c
    ./Driver/Motor/: Motor.c
    ./Driver/MPU6050/: MPU6050.c
    ./Driver/nRF24L01/: NRF24L01.c
    ./Driver/OLED/: OLED.c
    ./Driver/PWM/: PWM.c
    ./Driver/UART/: UART.c
    ./Driver/SysDelay/: delay.c
  group User
    ./User/: main.c
    ./User/Config/: stm32f10x_it.c
